# Keil uVision project metal.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: metal +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Listings;.\USER;.\USER\OLED;.\USER\MOTOR;.\USER\TIMER;.\USER\ADC;.\USER\UART;.\USER\EEPROM
  group main
    ./: STARTUP.A51
    ./USER/: main.c
  group OLED
    ./USER/OLED/: oled.c
  group adc
    ./USER/adc/: adc.C
  group MOTOR
    ./USER/MOTOR/: MOTOR.c
  group TIMER
    ./USER/TIMER/: timer.c
  group EEPROM
    ./USER/EEPROM/: eeprom.c
